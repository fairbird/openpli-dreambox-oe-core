SRC_URI[dreamtwo.md5sum] = "a190b1d07b08c25bf6660a7b7057d9f2"
SRC_URI[dreamtwo.sha256sum] = "1fe751b39429a51f31657b4c3b98f2acb13c1299f999a0593641b71a4c7e315d"

require dreambox-dvb-modules-meson.inc

COMPATIBLE_MACHINE = "^(dreamtwo)$"
