require recovery.inc

SRCREV = "fbd0c5f9fd98dc2c5d394ddb41c43fca9a58989f"

inherit opendreambox-git

BRANCH = "master"
