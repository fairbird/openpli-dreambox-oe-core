SRC_URI[dreamone.md5sum] = "3651abcece85309921017f7aad331be3"
SRC_URI[dreamone.sha256sum] = "c2b84a3e2750719b78c4d2b447e1b2300f60a3eb39b5b1ee0b45d7adf472562b"

require dreambox-dvb-modules-meson.inc

COMPATIBLE_MACHINE = "^(dreamone)$"
