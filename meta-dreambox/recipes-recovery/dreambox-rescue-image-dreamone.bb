require dreambox-rescue.inc

COMPATIBLE_MACHINE = "^(dreamone)$"
