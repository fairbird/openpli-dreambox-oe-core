SKINNAME = "WOWCataclysm_FHD"

require raed-skins.inc
require skin-python.inc
