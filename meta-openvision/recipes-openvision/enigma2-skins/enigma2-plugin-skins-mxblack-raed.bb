SKINNAME = "MX_black"

require raed-skins.inc
