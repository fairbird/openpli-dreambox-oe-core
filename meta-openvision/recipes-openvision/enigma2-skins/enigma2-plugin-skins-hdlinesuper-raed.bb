SKINNAME = "hdline-super"

require raed-skins.inc
require skin-python.inc
