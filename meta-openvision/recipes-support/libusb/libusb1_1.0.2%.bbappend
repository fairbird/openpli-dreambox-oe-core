PACKAGECONFIG_class-target ??= ""

EXTRA_OECONF = "--libdir=${base_libdir} --disable-udev"
