KERNEL_CC:append = " -std=gnu11"
