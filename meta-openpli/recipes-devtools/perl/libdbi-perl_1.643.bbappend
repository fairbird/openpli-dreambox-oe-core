INSANE_SKIP_${PN} += "file-rdeps"
