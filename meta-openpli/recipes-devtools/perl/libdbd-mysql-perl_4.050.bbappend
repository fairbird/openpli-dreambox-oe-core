CFLAGS += "-Wno-error=incompatible-pointer-types \
	   -Wno-error=deprecated-declarations \
"
