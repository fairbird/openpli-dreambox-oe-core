include python3-package-split.inc

DEPENDS += "python3-wheel-native"
