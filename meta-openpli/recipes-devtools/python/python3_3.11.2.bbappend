SRC_URI:remove = "http://www.python.org/ftp/python/3.11.2/Python-3.11.2.tar.xz"
SRC_URI:append = " http://www.python.org/ftp/python/3.11.3/Python-3.11.3.tar.xz"

SRC_URI[sha256sum] = "8a5db99c961a7ecf27c75956189c9602c968751f11dbeae2b900dbff1c085b5e"

PV = "3.11.3"
PKGV = "3.11.3"
