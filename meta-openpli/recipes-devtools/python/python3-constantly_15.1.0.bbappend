PV = "23.10.4"

DEPENDS = "python3-versioneer-native"

SRC_URI[md5sum] = "c090579309b2b34be04385b54b0a5a85"
SRC_URI[sha256sum] = "aa92b70a33e2ac0bb33cd745eb61776594dc48764b06c35e0efd050b7f1c7cbd"

include python3-package-split.inc
