RDEPENDS:${PN}:class-target:remove = "\
	cpp \
	cpp-symlinks \
"

include ${PYTHON_PN}-package-split.inc
