INSANE_SKIP:${PN} = "unknown-configure-option"
