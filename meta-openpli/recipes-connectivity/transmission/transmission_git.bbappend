SRC_URI = " \
	gitsm://github.com/transmission/transmission;branch=main;protocol=https \
	file://transmission-daemon \
"
