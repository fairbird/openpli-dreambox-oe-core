DEPENDS += "python3-scikit-build-core-native ninja-native python3-cmake-native"

inherit python_pep517 python3targetconfig
