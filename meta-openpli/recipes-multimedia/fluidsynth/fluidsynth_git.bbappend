SRC_URI:remove ="git://github.com/FluidSynth/fluidsynth.git;branch=2.2.x;protocol=https"
SRC_URI:append = " git://github.com/FluidSynth/fluidsynth.git;branch=master;protocol=https"
