FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://streamrelay-libdvbcsa.patch"
