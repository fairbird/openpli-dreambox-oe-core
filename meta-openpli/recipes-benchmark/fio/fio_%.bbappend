EXTRA_OEMAKE += "LDFLAGS='-latomic'"
