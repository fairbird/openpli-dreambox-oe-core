ALTERNATIVE_${PN} = ""
