INSANE_SKIP:${PN}-tools += "file-rdeps"
