INSANE_SKIP_${PN}-tools += "file-rdeps"
