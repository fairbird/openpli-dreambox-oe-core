MODULE = "UsbFormatWizard"
DESCRIPTION = "Wizard to Format Usb devices "

PV_MOD = "1.0+git"
PKGV_MOD = "1.0+git${GITPKGV}"

require conf/license/license-gplv2.inc
require openplugins-distutils.inc
