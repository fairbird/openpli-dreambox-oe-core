MODULE = "AddStreamUrl"
DESCRIPTION = "Add a stream url to your channellist"

require openplugins.inc

inherit setuptools3-openplugins
