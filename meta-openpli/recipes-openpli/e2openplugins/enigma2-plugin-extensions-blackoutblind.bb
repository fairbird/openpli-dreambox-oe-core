MODULE = "Blackoutblind"
DESCRIPTION = "Hide white dotted lines (VBI) on top of the screen"

PV_MOD = "1.0+git"
PKGV_MOD = "1.0+git${GITPKGV}"

require conf/license/license-gplv2.inc
require openplugins.inc
require openplugins-distutils.inc

BRANCH = "master"
