MODULE = "SetPicon"
DESCRIPTION = "Work with services picons"

require openplugins.inc
inherit setuptools3-openplugins
