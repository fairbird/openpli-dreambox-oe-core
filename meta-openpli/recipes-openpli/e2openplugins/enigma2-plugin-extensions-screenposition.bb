MODULE = "ScreenPosition"
DESCRIPTION = "Adjust the screen position"
PACKAGE_ARCH = "${MACHINE_ARCH}"

require openplugins.inc
inherit setuptools3-openplugins
