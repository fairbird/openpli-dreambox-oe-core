MODULE = "TelekomSport"
DESCRIPTION = "Telekom Sport Plugin"

require openplugins.inc
inherit setuptools3-openplugins
