MODULE = "XPower"
DESCRIPTION = "remote PC power management for win and linux"

require openplugins.inc
inherit setuptools3-openplugins
