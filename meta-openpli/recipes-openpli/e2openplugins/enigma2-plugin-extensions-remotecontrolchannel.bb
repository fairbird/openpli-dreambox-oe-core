MODULE = "RemoteControlChannel"
DESCRIPTION = "Remote control ir channel selection"

require openplugins.inc
inherit setuptools3-openplugins
