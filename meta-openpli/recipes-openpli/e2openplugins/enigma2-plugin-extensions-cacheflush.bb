MODULE = "CacheFlush"
DESCRIPTION = "periodicaly flushing cache"

require openplugins.inc
inherit setuptools3-openplugins
