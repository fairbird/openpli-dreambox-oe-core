MODULE = "MeteoViewer"
DESCRIPTION = "meteo pictures viewer"

require openplugins.inc
inherit setuptools3-openplugins
