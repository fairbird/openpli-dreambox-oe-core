MODULE = "WakeOnLan"
DESCRIPTION = "Send a WOL packet to devices"

PV_MOD = "1.0+git"
PKGV_MOD = "1.0+git${GITPKGV}"

require openplugins.inc
require openplugins-distutils.inc
