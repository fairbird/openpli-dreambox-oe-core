MODULE = "PermanentVfdClock"
DESCRIPTION = "Show clock in VFD permanently"

require openplugins.inc
inherit setuptools3-openplugins
