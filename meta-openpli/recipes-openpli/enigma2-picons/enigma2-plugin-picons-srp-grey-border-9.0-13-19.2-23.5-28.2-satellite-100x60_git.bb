DESCRIPTION = "srp grey border 9.0 13 19.2 23.5 28.2 satellite 100x60"
MAINTAINER = "Stefan"
LICENSE = "Proprietary"
LIC_FILES_CHKSUM = "file://LICENSE;beginline=3;endline=8;md5=17213e93942fd27819359eebdf0341b7"

require enigma2-plugin-picons-ziggo.inc

SRC_URI = "git://github.com/Hains/srp.100x60.grey-border-9.0-13-19.2-23.5-28.2-satellite"
