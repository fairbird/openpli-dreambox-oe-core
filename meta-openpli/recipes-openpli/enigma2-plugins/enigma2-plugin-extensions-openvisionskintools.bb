DESCRIPTION = "OpenVision skin tools by RAED"
LICENSE = "GPLv3"
LIC_FILES_CHKSUM = "file://LICENSE;md5=1ebbd3e34237af26da5dc08a4e440464"

inherit gitpkgv distutils-openplugins gettext

PV = "git${SRCPV}"
PKGV = "git${GITPKGV}"

SRC_URI = "git://github.com/OpenVisionE2/OpenVisionSkinTools.git;protocol=git"

FILES_${PN} = "${libdir}"

S = "${WORKDIR}/git"
