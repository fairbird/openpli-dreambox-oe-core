SUMMARY = "Plugin to handle the MSNWeather Converter and Renderer for displaying MSN-Weather in Skin"
DESCRIPTION = ""
LICENSE = "CLOSED"

inherit allarch

ALLOW_EMPTY:${PN} = "1"
