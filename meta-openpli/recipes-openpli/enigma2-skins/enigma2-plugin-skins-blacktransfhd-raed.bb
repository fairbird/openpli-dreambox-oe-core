SKINNAME = "BlackTransFULLHD"

require raed-skins.inc
