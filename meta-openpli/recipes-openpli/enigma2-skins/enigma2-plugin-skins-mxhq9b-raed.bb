SKINNAME = "MX_HQ9B"

require raed-skins.inc
