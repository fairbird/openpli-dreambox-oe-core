SKINNAME = "WhiteTransFullHD"

require raed-skins.inc
