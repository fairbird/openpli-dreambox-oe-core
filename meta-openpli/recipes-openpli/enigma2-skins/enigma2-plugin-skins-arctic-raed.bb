SKINNAME = "Arctic"

require raed-skins.inc
