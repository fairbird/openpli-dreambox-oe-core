SKINNAME = "slyk_1080"

require raed-skins.inc
require skin-python.inc
