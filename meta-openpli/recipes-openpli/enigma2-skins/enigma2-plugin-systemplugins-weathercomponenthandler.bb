SUMMARY = "Plugin to handle the MSNWeather Converter and Renderer for displaying MSN-Weather in Skin"

require conf/license/license-gplv2.inc

inherit allarch

ALLOW_EMPTY:${PN} = "1"
