SKINNAME = "MaxFullHDXTA"

require raed-skins.inc
require skin-python.inc
