SKINNAME = "AtileHD"

require raed-skins.inc
require skin-python.inc
