SKINNAME = "Multibox"

require raed-skins.inc
require skin-python.inc
