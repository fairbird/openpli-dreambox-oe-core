SKINNAME = "MX_Sline"

require raed-skins.inc
require skin-python.inc
