SKINNAME = "BundesligaFHD"

require raed-skins.inc
require skin-python.inc
