PACKAGEINDEXDEPS += "openpli-enigma2-feed:do_rm_work"

require package-index.bb
