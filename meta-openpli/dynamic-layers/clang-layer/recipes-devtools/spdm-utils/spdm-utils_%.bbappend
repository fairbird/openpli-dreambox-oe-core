COMPATIBLE_HOST:mipsarcho32 = "null"
