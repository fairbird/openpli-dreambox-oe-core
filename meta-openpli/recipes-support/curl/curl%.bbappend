WARN_QA:remove ="invalid-packageconfig"
