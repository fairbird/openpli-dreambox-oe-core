PACKAGECONFIG:class-target = "libidn openssl proxy random threaded-resolver verbose zlib"
