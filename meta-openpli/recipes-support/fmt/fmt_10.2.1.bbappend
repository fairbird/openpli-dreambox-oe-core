LIC_FILES_CHKSUM = "file://LICENSE;md5=b9257785fc4f3803a4b71b76c1412729"

SRC_URI = "git://github.com/fmtlib/fmt;branch=release;protocol=https"

SRCREV = "0041a40c1350ba702d475b9c4ad62da77caea164"

PV = "11.0.0"
