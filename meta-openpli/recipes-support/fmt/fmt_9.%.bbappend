LIC_FILES_CHKSUM = "file://LICENSE.rst;md5=b9257785fc4f3803a4b71b76c1412729"

SRCREV = "a425e0ff3bf552145854f60eeda895b3613e7c42"

PV = "10.0.0"
PKGV = "10.0.0"
