DEPENDS += "zlib eudev"
