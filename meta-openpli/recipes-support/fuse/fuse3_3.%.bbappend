EXTRA_OEMESON:append = " -Dexamples=false"
